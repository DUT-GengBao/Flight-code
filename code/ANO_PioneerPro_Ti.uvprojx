# Keil uVision project ANO_PioneerPro_Ti.uvprojx, settings and files
target AnoPioneerProTi (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ANO_PioneerPro_Ti
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TARGET_IS_TM4C123_RB1 PART_TM4C123GH6PM
  c include: .\TiDriver\inc;.\TiDriver\inc\driver_inc;.\TiDriver\inc\driver_hw;.\TiDriver\inc\driver_usb;.\TiDriver\inc\driver_usb\device;.\Application;.\Driver;.\Driver\SenserDriver;.\SRC\fc_general;.\SRC\fc_specific
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Application
    ./Application/: main.c sysconfig.h Ano_Scheduler.c Ano_Scheduler.h Ano_Parameter.c Ano_Parameter.h Ano_FlyCtrl.c Ano_FlyCtrl.h Ano_DT.c Ano_DT.h Ano_RC.c Ano_RC.h Ano_LED.c Ano_LED.h Ano_Usb.c Ano_Usb.h Ano_ProgramCtrl_User.c Ano_ProgramCtrl_User.h Ano_OF_DecoFusion.c Ano_OF_DecoFusion.h Ano_OPMV_CBTracking_Ctrl.c Ano_OPMV_CBTracking_Ctrl.h Ano_OPMV_LineTracking_Ctrl.c Ano_OPMV_LineTracking_Ctrl.h Ano_OPMV_Ctrl.c Ano_OPMV_Ctrl.h uartstdio.c my_task.c my_task.h Ano_OPMV_CBTracking_Ctrl2.h Ano_OPMV_CBTracking_Ctrl2.c
  group TiDriver
    ./TiDriver/src/: startup_TM4C123.s system_TM4C123.c usb_serial_structs.c
    ./TiDriver/inc/: usb_serial_structs.h
    ./TiDriver/: driverlib.lib usblib.lib
  group Driver
    ./Driver/: Drv_Bsp.c Drv_Bsp.h Drv_Adc.c Drv_Adc.h Drv_Led.c Drv_Led.h Drv_Paramter.c Drv_Paramter.h Drv_RcIn.c Drv_RcIn.h Drv_PwmOut.c Drv_PwmOut.h Drv_Spi.c Drv_Spi.h Drv_Uart.c Drv_Uart.h Ws2812.c Ws2812.h Drv_key.c Drv_key.h Drv_beep.c Drv_beep.h
  group SenserDriver
    ./Driver/SenserDriver/: Drv_icm20602.c Drv_icm20602.h Drv_ak8975.c Drv_ak8975.h Drv_spl06.c Drv_spl06.h Drv_gps.c Drv_gps.h Ano_OF.c Ano_OF.h Ano_UWB.c Ano_UWB.h Drv_heating.c Drv_heating.h Drv_OpenMV.c Drv_OpenMV.h Drv_UP_Flow.c Drv_UP_Flow.h Drv_laser.c Drv_laser.h Drv_OpenMV2.c Drv_OpenMV2.h
  group FC_General
    ./SRC/fc_general/: Ano_FcData.c Ano_FcData.h Ano_Filter.c Ano_Filter.h Ano_Math.c Ano_Math.h Ano_Pid.c Ano_Pid.h Ano_Imu.c Ano_Imu.h Ano_Sensor_Basic.c Ano_Sensor_Basic.h Ano_MotionCal.c Ano_MotionCal.h Ano_Navigate.c Ano_Navigate.h
  group FC_Specific
    ./SRC/fc_specific/: config.h Ano_AltCtrl.c Ano_AltCtrl.h Ano_AttCtrl.c Ano_AttCtrl.h Ano_FlightCtrl.c Ano_FlightCtrl.h Ano_FlightDataCal.c Ano_FlightDataCal.h Ano_LocCtrl.c Ano_LocCtrl.h Ano_MagProcess.c Ano_MagProcess.h Ano_MotorCtrl.c Ano_MotorCtrl.h Ano_Power.c Ano_Power.h
